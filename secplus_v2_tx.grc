options:
  parameters:
    generate_options: no_gui
    id: secplus_v2_tx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: seq
  id: variable
  parameters:
    value: '[0]*200 + secplus.encode_v2_manchester(rolling, fixed, None if data == -1 else data)*3 + [0]*200'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: 300e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '500'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: seq
  states: {}
- name: data
  id: parameter
  parameters:
    label: Data
    type: intx
    value: '-1'
  states: {}
- name: fixed
  id: parameter
  parameters:
    label: Fixed code
    type: intx
    value: '1234567890'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    short_id: f
    type: intx
    value: '315000000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import secplus
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '0'
    freq0: freq - 300e3
    gain0: '0'
    if_gain0: '47'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rolling
  id: parameter
  parameters:
    label: Rolling code
    type: intx
    value: '123456789'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.2'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_repeat_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
