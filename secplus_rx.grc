<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>secplus_rx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim1</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim2</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>315150000</value></param>
<param><key>label0</key><value>315 MHz</value></param>
<param><key>label1</key><value>390 MHz</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>315150000</value></param>
<param><key>option1</key><value>390150000</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>0.05</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>2 * math.pi * -300e3 / samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>32</value></param>
<param><key>bw0</key><value>1e6</value></param>
<param><key>freq0</key><value>freq - 300e3</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>32</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>100000 / decim1 / decim2</value></param>
<param><key>srate</key><value>samp_rate / decim1 / decim2</value></param>
<param><key>tr_level</key><value>threshold</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>decim1</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>decim2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[1.0/decim2]*decim2</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>secplus_decode</value></param>
<param><key>_source_code</key><value>#
# Copyright 2016 Clayton Smith (argilo@gmail.com)
#
# This file is part of secplus.
#
# secplus is free software: you can redistribute it and/or modify
# it under the terms of the GNU General Public License as published by
# the Free Software Foundation, either version 3 of the License, or
# (at your option) any later version.
#
# secplus is distributed in the hope that it will be useful,
# but WITHOUT ANY WARRANTY; without even the implied warranty of
# MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
# GNU General Public License for more details.
#
# You should have received a copy of the GNU General Public License
# along with secplus.  If not, see &lt;http://www.gnu.org/licenses/&gt;.
#

import numpy as np
from gnuradio import gr
import secplus


class blk(gr.sync_block):
    """Decoder for Chamberlain garage door openers"""

    def __init__(self, samp_rate=10000, threshold=0.02):
        gr.sync_block.__init__(
            self,
            name='Security+ Decoder',

            in_sig=[np.float32],
            out_sig=[]
        )
        self.samp_rate = samp_rate
        self.threshold = threshold
        self.last_sample = 0.0
        self.last_rise = 0
        self.buffer = []
        self.last_pair = []
        self.pair = []

    def work(self, input_items, output_items):
        for n, sample in enumerate(input_items[0]):
            current_sample = self.nitems_read(0) + n
            if self.last_sample &lt; self.threshold &lt;= sample:
                # rising edge
                self.last_rise = current_sample
            elif self.last_sample &gt;= self.threshold &gt; sample:
                # falling edge
                on_samples = current_sample - self.last_rise
                self.process_symbol(on_samples)
            if current_sample - self.last_rise &gt; 3.25e-3 * self.samp_rate:
                self.buffer = []
            self.last_sample = sample
        return len(input_items[0])

    def process_symbol(self, on_samples):
        if on_samples &lt; 0.35e-3 * self.samp_rate:
            self.buffer = []
        elif on_samples &lt; 0.75e-3 * self.samp_rate:
            self.buffer.append(0)
        elif on_samples &lt; 1.25e-3 * self.samp_rate:
            self.buffer.append(1)
        elif on_samples &lt; 1.75e-3 * self.samp_rate:
            self.buffer.append(2)
        else:
            self.buffer = []

        if len(self.buffer) == 21:
            self.process_buffer()
            self.buffer = []

    def process_buffer(self):
        if self.buffer[0] == 0:
            self.pair = self.buffer[1:21]
        elif len(self.pair) == 20 and self.buffer[0] == 2:
            self.pair += self.buffer[1:21]

        if len(self.pair) == 40 and self.pair != self.last_pair:
            rolling, fixed = secplus.decode(self.pair)
            print secplus.pretty(rolling, fixed)
            self.last_pair = self.pair
</value></param>
<param><key>samp_rate</key><value>samp_rate / decim1 / decim2</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>secplus_decode</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
