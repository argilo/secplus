options:
  parameters:
    generate_options: qt_gui
    id: secplus_rx
    output_language: python
  states: {}

blocks:
- name: decim1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: '50'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Frequency
    label0: 310 MHz
    label1: 315 MHz
    label2: 390 MHz
    label3: 433 MHz
    num_opts: '4'
    option0: '310150000'
    option1: '315150000'
    option2: '390150000'
    option3: '433920000'
    orient: Qt.QHBoxLayout
    type: int
    value: '315150000'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: Detection threshold
    start: '0.01'
    step: '0.01'
    stop: '1.00'
    value: '0.10'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * -300e3 / samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '32'
    bw0: 1e6
    freq0: freq - 300e3
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: 100000 // decim1 // decim2
    srate: samp_rate // decim1 // decim2
    tr_level: threshold
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim1
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: decim2
    interp: '1'
    taps: '[1.0/decim2]*decim2'
    type: fff
  states: {}
- name: secplus_decode
  id: epy_block
  parameters:
    _source_code: |
      #
      # Copyright 2016 Clayton Smith (argilo@gmail.com)
      #
      # This file is part of secplus.
      #
      # secplus is free software: you can redistribute it and/or modify
      # it under the terms of the GNU General Public License as published by
      # the Free Software Foundation, either version 3 of the License, or
      # (at your option) any later version.
      #
      # secplus is distributed in the hope that it will be useful,
      # but WITHOUT ANY WARRANTY; without even the implied warranty of
      # MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
      # GNU General Public License for more details.
      #
      # You should have received a copy of the GNU General Public License
      # along with secplus.  If not, see <http://www.gnu.org/licenses/>.
      #

      import numpy as np
      from gnuradio import gr
      if __name__ != "builtins":  # Don't import within GRC
          import secplus


      class blk(gr.sync_block):
          """Decoder for Chamberlain garage door openers"""

          def __init__(self, samp_rate=10000, threshold=0.02):
              gr.sync_block.__init__(
                  self,
                  name='Security+ Decoder',

                  in_sig=[np.float32],
                  out_sig=[]
              )
              self.samp_rate = samp_rate
              self.threshold = threshold
              self.last_sample = 0.0
              self.last_rise = 0
              self.buffer = []
              self.last_pair = []
              self.pair = []

          def work(self, input_items, output_items):
              for n, sample in enumerate(input_items[0]):
                  current_sample = self.nitems_read(0) + n
                  if self.last_sample < self.threshold <= sample:
                      # rising edge
                      self.last_rise = current_sample
                  elif self.last_sample >= self.threshold > sample:
                      # falling edge
                      on_samples = current_sample - self.last_rise
                      self.process_symbol(on_samples)
                  if current_sample - self.last_rise > 3.25e-3 * self.samp_rate:
                      self.buffer = []
                  self.last_sample = sample
              return len(input_items[0])

          def process_symbol(self, on_samples):
              if on_samples < 0.35e-3 * self.samp_rate:
                  self.buffer = []
              elif on_samples < 0.75e-3 * self.samp_rate:
                  self.buffer.append(0)
              elif on_samples < 1.25e-3 * self.samp_rate:
                  self.buffer.append(1)
              elif on_samples < 1.75e-3 * self.samp_rate:
                  self.buffer.append(2)
              else:
                  self.buffer = []

              if len(self.buffer) == 21:
                  self.process_buffer()
                  self.buffer = []

          def process_buffer(self):
              if self.buffer[0] == 0:
                  self.pair = self.buffer[1:21]
              elif len(self.pair) == 20 and self.buffer[0] == 2:
                  self.pair += self.buffer[1:21]

              if len(self.pair) == 40 and self.pair != self.last_pair:
                  rolling, fixed = secplus.decode(self.pair)
                  print(secplus.pretty(rolling, fixed))
                  self.last_pair = self.pair
    samp_rate: samp_rate // decim1 // decim2
    threshold: threshold
  states: {}
- name: secplus_v2_decode
  id: epy_block
  parameters:
    _source_code: |
      #
      # Copyright 2020 Clayton Smith (argilo@gmail.com)
      #
      # This file is part of secplus.
      #
      # secplus is free software: you can redistribute it and/or modify
      # it under the terms of the GNU General Public License as published by
      # the Free Software Foundation, either version 3 of the License, or
      # (at your option) any later version.
      #
      # secplus is distributed in the hope that it will be useful,
      # but WITHOUT ANY WARRANTY; without even the implied warranty of
      # MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
      # GNU General Public License for more details.
      #
      # You should have received a copy of the GNU General Public License
      # along with secplus.  If not, see <http://www.gnu.org/licenses/>.
      #

      import numpy as np
      from gnuradio import gr
      if __name__ != "builtins":  # Don't import within GRC
          import secplus


      class blk(gr.sync_block):
          """Decoder for Chamberlain garage door openers"""

          def __init__(self, samp_rate=10000, threshold=0.02):
              gr.sync_block.__init__(
                  self,
                  name='Security+ 2.0 Decoder',

                  in_sig=[np.float32],
                  out_sig=[]
              )
              self.samp_rate = samp_rate
              self.threshold = threshold
              self.last_sample = 0.0
              self.last_edge = 0
              self.buffer = []
              self.pair = [None, None]
              self.pair_time = [None, None]

          def work(self, input_items, output_items):
              for n, sample in enumerate(input_items[0]):
                  current_sample = self.nitems_read(0) + n
                  if self.last_sample < self.threshold <= sample:
                      # rising edge
                      self.process_edge(True, current_sample - self.last_edge)
                      self.last_edge = current_sample
                  elif self.last_sample >= self.threshold > sample:
                      # falling edge
                      self.process_edge(False, current_sample - self.last_edge)
                      self.last_edge = current_sample
                  if current_sample - self.last_edge >= 0.625e-3 * self.samp_rate:
                      self.buffer.append(0)
                      self.buffer.append(0)
                      self.process_buffer(current_sample)
                      self.buffer = []
                  self.last_sample = sample
              return len(input_items[0])

          def process_edge(self, rising, samples):
              if samples < 0.125e-3 * self.samp_rate:
                  pass
              elif samples < 0.375e-3 * self.samp_rate:
                  self.buffer.append(0 if rising else 1)
              elif samples < 0.625e-3 * self.samp_rate:
                  self.buffer.append(0 if rising else 1)
                  self.buffer.append(0 if rising else 1)

          def process_buffer(self, current_sample):
              manchester = "".join(str(b) for b in self.buffer)
              start = manchester.find("1010101001010101")
              if start == -1:
                  return

              if manchester[start+20:start+24] == "1010":
                  packet_length = 40
              elif manchester[start+20:start+24] == "1001":
                  packet_length = 64
              else:
                  return

              manchester = manchester[start+16:start+20+(packet_length*2)]
              baseband = []
              for i in range(0, len(manchester), 2):
                  if manchester[i:i+2] == "01":
                      baseband.append(1)
                  elif manchester[i:i+2] == "10":
                      baseband.append(0)
                  else:
                      return
              packet = baseband[2:]

              if baseband[0:2] == [0, 0]:
                  frame_id = 0
              elif baseband[0:2] == [0, 1]:
                  frame_id = 1
              else:
                  return

              self.pair_time[frame_id] = current_sample

              if self.pair[frame_id] == packet:
                  return

              self.pair[frame_id] = packet
              
              if (self.pair[frame_id ^ 1] is not None) and (len(self.pair[frame_id ^ 1]) == packet_length):
                  if self.pair_time[frame_id] - self.pair_time[frame_id ^ 1] < 0.35 * self.samp_rate:
                      try:
                          rolling, fixed, data = secplus.decode_v2(self.pair[0] + self.pair[1])
                          print(secplus.pretty_v2(rolling, fixed, data))
                      except ValueError:
                          pass
    samp_rate: samp_rate // decim1 // decim2
    threshold: threshold
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', rational_resampler_xxx_1, '0']
- [blocks_rotator_cc_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_rotator_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', secplus_decode, '0']
- [rational_resampler_xxx_1, '0', secplus_v2_decode, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
